# Keil uVision project timer2_inter.uvproj, settings and files
target timer2_inter (MCS-51)
  device: T80C51 Microchip
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(44000000)
  output: timer2_inter +hex
  c flags: Optimize=8 SizeSpeed=1
  group SYSTEM
    ./: STARTUP.A51
  group USER
    ../USER/: main.c
